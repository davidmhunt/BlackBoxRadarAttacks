options:
  parameters:
    generate_options: qt_gui
    id: receive_link_budget_calibration
    output_language: python
    title: receive_link_budget_calibration
  states: {}

blocks:
- name: Rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: device_address
  id: variable
  parameters:
    value: '"serial=3231EFC"'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 3e9
  states: {}
- name: measurement_time_ms
  id: variable
  parameters:
    value: '10'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: round(measurement_time_ms * 1e-3 * samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: samp_rate
    type: float
  states: {}
- name: average_power_db
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Average Power (dB)"'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: num_samples
    max_iter: num_samples
    scale: samp_rate/num_samples
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '-174'
    n: '10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: frequency
    dev_addr: device_address
    gain0: Rx_gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_add_xx_0, '0', average_power_db, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_xx_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_add_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-452-g0f205085
